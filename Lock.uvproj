# Keil uVision project Lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Lock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Boot
    ./: STARTUP.A51
  group Source
    ./: main.c
  group include
    ./: 12864.c key.c
